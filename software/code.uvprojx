# Keil uVision project code.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: code
  AfterMake: fromelf --bin code.axf -o code.bin
  AfterMake: fromelf -cvf code.axf --vhx --32x1 -o code.mem
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c include: .\core;.\device;.\application
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application
    ./Application/: main.c
  group Device
    ./device/: cm0dsasm.s edk_driver.c retarget.c edk_api.c
software components: CMSIS:CORE 5.1.1
